<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\imu_ekf_rm_aboard.ewp</path>
  </project>
  <batchBuild />
</workspace>
