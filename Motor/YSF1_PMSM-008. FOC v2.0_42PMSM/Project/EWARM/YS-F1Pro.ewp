# IAR project YS-F1Pro.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\User\bsp; ..\..\User; ..\..\STM32_PMSM_FOC_LIBv2.0\inc; ..\..\Libraries\CMSIS\CMSIS_2_x\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: YS-F1Pro.out
  ILINK.IlinkIcfFile: stm32f10xE_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group BSP
    ../../User/bsp/: bsp_lcd.c bsp_touch.c
  group CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Motor control/include
    ../../STM32_PMSM_FOC_LIBv2.0/inc/: MC_Clarke_Park.h MC_const.h MC_Display.h MC_FOC_Drive.h MC_FOC_Methods.h MC_Globals.h MC_Keys.h MC_MotorControl_Layer.h MC_PID_regulators.h MC_State_Observer.h MC_State_Observer_Interface.h MC_type.h stm32f10x_encoder.h stm32f10x_hall.h stm32f10x_MCdac.h stm32f10x_MClib.h stm32f10x_svpwm_1shunt.h stm32f10x_svpwm_3shunt.h stm32f10x_svpwm_ics.h stm32f10x_Timebase.h
  group Motor control/library
    ../../STM32_PMSM_FOC_LIBv2.0/lib/: MC_FOC_Methods.o MC_State_Observer.o
  group Motor control/parameters .h files
    ../../STM32_PMSM_FOC_LIBv2.0/inc/: MC_Control_Param.h MC_encoder_param.h MC_hall_prm.h MC_PMSM_motor_param.h MC_pwm_1shunt_prm.h MC_pwm_3shunt_prm.h MC_pwm_ics_prm.h MC_State_Observer_param.h STM32F10x_MCconf.h
  group Motor control/source
    ../../STM32_PMSM_FOC_LIBv2.0/src/: MC_Clarke_Park.c MC_Display.c MC_FOC_Drive.c MC_Globals.c MC_Keys.c MC_MotorControl_Layer.c MC_PID_regulators.c MC_State_Observer_Interface.c stm32f10x_encoder.c stm32f10x_hall.c stm32f10x_MCdac.c stm32f10x_svpwm_1shunt.c stm32f10x_svpwm_3shunt.c stm32f10x_svpwm_ics.c stm32f10x_Timebase.c
  group Startup
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
  group StdPeriph_Derive
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../../User/: main.c stm32f10x_it.c
