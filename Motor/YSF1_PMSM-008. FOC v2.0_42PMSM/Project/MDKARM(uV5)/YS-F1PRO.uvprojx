# Keil uVision project YS-F1PRO.uvprojx, settings and files
target YS-F1PRO (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: YS-F1PRO +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\User;..\..\STM32_PMSM_FOC_LIBv2.0\inc;..\..\User\bsp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group StdPeriph_Derive
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../../User/: main.c stm32f10x_it.c
  group bsp
    ../../User/bsp/: bsp_lcd.c bsp_touch.c
  group foc_lib
    ../../STM32_PMSM_FOC_LIBv2.0/lib/: MC_FOC_Methods_lib.lib MC_State_Observer_lib.lib
  group foc_include
    ../../STM32_PMSM_FOC_LIBv2.0/inc/: MC_MotorControl_Layer.h MC_Clarke_Park.h MC_const.h MC_Display.h MC_FOC_Drive.h MC_Globals.h MC_Keys.h MC_PID_regulators.h MC_State_Observer.h MC_State_Observer_Interface.h MC_type.h stm32f10x_encoder.h stm32f10x_hall.h stm32f10x_MCdac.h stm32f10x_MClib.h stm32f10x_svpwm_1shunt.h stm32f10x_svpwm_3shunt.h stm32f10x_svpwm_ics.h stm32f10x_Timebase.h
  group foc_source
    ../../STM32_PMSM_FOC_LIBv2.0/src/: MC_Clarke_Park.c MC_Display.c MC_FOC_Drive.c MC_Globals.c MC_Keys.c MC_MotorControl_Layer.c MC_PID_regulators.c MC_State_Observer_Interface.c stm32f10x_encoder.c stm32f10x_hall.c stm32f10x_MCdac.c stm32f10x_svpwm_1shunt.c stm32f10x_svpwm_3shunt.c stm32f10x_svpwm_ics.c stm32f10x_Timebase.c
  group foc_parameters .h files
    ../../STM32_PMSM_FOC_LIBv2.0/inc/: MC_Control_Param.h MC_encoder_param.h MC_hall_prm.h MC_PMSM_motor_param.h MC_pwm_1shunt_prm.h MC_pwm_3shunt_prm.h MC_pwm_ics_prm.h MC_State_Observer_param.h STM32F10x_MCconf.h
  group Readme
    ../../Readme/: 01.例程功能说明.txt 02.开发环境说明.txt
