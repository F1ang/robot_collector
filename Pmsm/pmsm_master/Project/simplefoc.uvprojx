# Keil uVision project simplefoc.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: simplefoc +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Drivers\CMSIS\CM3\CoreSupport;..\Drivers\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Drivers\STM32F10x_StdPeriph_Driver\inc;..\User;..\SimpleFOC\inc;..\BSP\inc;..\BSP\systick\inc;..\BSP\uselib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c stm32f10x_it.c
  group CMSIS
    ../Drivers/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Drivers/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Drivers
    ../Drivers/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Bsp
    ../BSP/src/: bsp_led.c bsp_tim.c bsp_usart.c bsp_motor.c
  group Uselib
    ../BSP/uselib/src/: math.c pid.c protocol.c
  group Systick
    ../BSP/systick/src/: delay.c sys.c
  group Foc_lib
    ../SimpleFOC/lib/: MC_FOC_Methods_lib.lib MC_State_Observer_lib.lib
  group Foc_inc
    ../SimpleFOC/inc/: MC_Clarke_Park.h MC_const.h MC_Display.h MC_FOC_Drive.h MC_FOC_Methods.h MC_Globals.h MC_Keys.h MC_MotorControl_Layer.h MC_PID_regulators.h MC_State_Observer.h MC_State_Observer_Interface.h MC_type.h stm32f10x_encoder.h stm32f10x_hall.h stm32f10x_MCdac.h stm32f10x_MClib.h stm32f10x_svpwm_1shunt.h stm32f10x_svpwm_3shunt.h stm32f10x_svpwm_ics.h stm32f10x_Timebase.h
  group Foc_src
    ../SimpleFOC/src/: MC_Clarke_Park.c MC_Display.c MC_FOC_Drive.c MC_Globals.c MC_Keys.c MC_MotorControl_Layer.c MC_PID_regulators.c MC_State_Observer_Interface.c stm32f10x_encoder.c stm32f10x_hall.c stm32f10x_MCdac.c stm32f10x_svpwm_1shunt.c stm32f10x_svpwm_3shunt.c stm32f10x_svpwm_ics.c stm32f10x_Timebase.c
  group Foc_para_conf
    ../SimpleFOC/inc/: MC_Control_Param.h MC_encoder_param.h MC_hall_prm.h MC_PMSM_motor_param.h MC_pwm_1shunt_prm.h MC_pwm_3shunt_prm.h MC_pwm_ics_prm.h MC_State_Observer_param.h STM32F10x_MCconf.h
  group Startup
    ../Drivers/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
